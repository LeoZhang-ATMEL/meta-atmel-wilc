FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Update-WILC-driver-to-15_2_rc1.patch \
            file://0002-Add-sama5d2-xplained-wilc-demo-dts.patch \
            file://0003-Add-sama5d27_som1_ek-wlic-dts.patch \
	    file://0004-Update-Makefile-for-invalid-under-score.patch"
